RPROVIDES += "python3-modules-native"
